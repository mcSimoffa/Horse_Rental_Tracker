# IAR project proj4.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: D:\My\_Radio\ProjectS\HorseMeter\Horse4_RTOS
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: source\rtos\include; source\include; include; $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  AARM.AUserIncludes: source\rtos; source; $PROJ_DIR$
  OBJCOPY.OOCOutputFile: proj4.srec
  group (top)
    ./: main.c
  group source
    source/: Cfunction.c SenseButton.c SIM800Lib.c startup_stm32f10x_md.s stm32f10x_dma_dihalt.c stm32F10x_gpioMY.c stm32F10x_usart1.c system_stm32f10x.c telemetry.c
  group source/RTOS
    source/rtos/: croutine.c event_groups.c heap_1.c list.c port.c portasm.s queue.c stream_buffer.c tasks.c timers.c
